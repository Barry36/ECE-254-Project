# Keil uVision project RTX_App.uvproj, settings and files
target Starter RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_APP
  c flags: Optim=1
  c define: MYSIM
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: RTX_Conf_CM.c Retarget.c system_LPC17xx.c uart_polling.c
  group Source Code
    ./src/: main_task_exp.c
  group Helpers
    ./src/: lab2_helper.c
  group RTX Lib
    ../RTX_CM3/CM3_LE/: RTX_CM3.lib
  group Doc
    ./: Test_spec.txt
target Starter SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: RTX_APP
  c flags: Optim=1
  c define: MYSIM
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
